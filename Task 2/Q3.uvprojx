# Keil uVision project Q3.uvprojx, settings and files
target Q3 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: STM32F303VCTx STMicroelectronics
  pack: Keil.STM32F3xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x0000C000) IRAM2(0x10000000,0x00002000) IROM(0x08000000,0x00040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: Q3
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=2
  c define: USE_HAL_DRIVER,STM32F303xC,USE_STM32F3_DISCO,
  c misc: --C99 --cpu Cortex-M7.fp.sp --fpu=FPv4-SP
  c include: Inc;Drivers\STM32F3xx_HAL_Driver\Inc;Drivers\BSP\STM32F3-Discovery;Drivers\CMSIS\Device\ST\STM32F3xx\Include;Drivers\CMSIS\Include;GPIO\Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0xc000
  memory RVCT10: RAM 0x10000000 size 0x2000
  link misc: --diag_suppress=L6329
  group Doc
    ./Docs/: direct IO access.txt
  group HAL
    ./Drivers/STM32F3xx_HAL_Driver/Src/: stm32f3xx_hal.c stm32f3xx_hal_cortex.c stm32f3xx_hal_dma.c stm32f3xx_hal_gpio.c stm32f3xx_hal_rcc.c stm32f3xx_hal_i2c.c
  group GPIO
    ./GPIO/Src/: gpio_setup.c stm32f3xx_it.c
  group Src
    ./Src/: Q3.c
software components: CMSIS:CORE 5.3.0, CMSIS:RTOS:Keil RTX5 5.5.1, CMSIS:RTOS2:Keil RTX5 5.5.1, Device:Startup 1.0.0
